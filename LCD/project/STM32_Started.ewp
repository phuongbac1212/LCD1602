# IAR project STM32_Started.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.CCIncludePath2: ..\CMSIS\Include; ..\STM32F10x; ..\source; ..\usr_lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32_Started.hex
  ILINK.IlinkOutputFile: STM32_Started.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source
    ../source/: main.c
  group startup
    ../STM32F10x/: startup_stm32f10x_md.s system_stm32f10x.c system_stm32f10x.h
  group usr_lib
    ../usr_lib/: LCD.c LCD.h user_delay.c user_delay.h
